## src/examples/inject_test/Kconfig
```kconfig
menuconfig EXAMPLES_INJECT_TEST
	bool "inject_test"
	default n
	---help---
		Idk
```
